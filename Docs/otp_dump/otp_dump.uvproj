# Keil uVision project otp_dump.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MAX32555 Maxim Integrated
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x10000020-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3") ELITTLE
  output: otp_dump +hex
  AfterMake: ..\..\tools\signit.bat "$K" "$L" "!L" "@L" $D
  c flags: Optim=1 uC99=1
  c include: src;../../drivers/max3255X/include;../../drivers/max3255X/include/arch;../../drivers/max3255X/include/dev;../../include
  memory RVCT4: ROM 0x10000020 size 0x7ffe0
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    src/: main.c printf_lite.c private.c
    ./src/: startup_max3255X.s
    ../../drivers/build/: libmml.lib
